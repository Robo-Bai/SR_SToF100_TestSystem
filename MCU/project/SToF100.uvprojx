# Keil uVision project SToF100.uvprojx, settings and files
target SToF100 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SToF100 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\libraries\STM32F10x_StdPeriph_Driver\inc;..\project;..\app;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\app\include;..\components\drivers\led_peripheral;..\components\drivers\blink;..\libraries\CMSIS\Device;..\components\drivers\sensor;..\components\drivers\exit;..\components\drivers\can;..\components\drivers\motor_kinco;..\components\drivers\SH200;..\components\drivers\led_peripheral
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./: main.c
  group components\drivers
    ../components/drivers/blink/: blink.c
    ../components/drivers/exit/: exti.c
    ../components/drivers/sensor/: sensor.c
    ../components/drivers/can/: can_SToF100.c
    ../components/drivers/motor_kinco/: motor_kinco.c
    ../components/drivers/SH200/: SH200.c
    ../components/drivers/led_peripheral/: led.c
  group libraries\StdPeriph_Driver
    ../libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../libraries/CMSIS/: core_cm3.c startup_stm32f10x_cl.s
    ../libraries/CMSIS/Device/: stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
